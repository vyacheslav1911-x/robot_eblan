Commit message: fix

File: src/roarm_description/urdf/roarm_m3/roarm_m3.xacro (robot description, xacro)
@@ -211,5 +211,5 @@
   <parent link="link5"/>
   <child link="gripper_link"/>
-  <axis xyz="0.0 -0.0 1.0"/>
+  <axis xyz="0.0 -0.0 -1.0"/>
   <limit
     lower="0"
